# IAR project Backup (2) of stm8dalislave.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ../../Libraries/DALIStack/inc; ../../Libraries/STM8S_StdPeriph_Driver/inc; ../../Project/inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8dalislave.srec
  ILINK.IlinkOutputFile: stm8dalislave.out
  ILINK.IlinkIcfFile: lnkstm8s105c6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group DALIStack/inc
    ../../Libraries/DALIStack/inc/: dali.h dali_cmd.h dali_config.h dali_pub.h dali_regs.h eeprom.h lite_timer_8bit.h
  group DALIStack/src
    ../../Libraries/DALIStack/src/: dali.c dali_cmd.c dali_config.c dali_pub.c dali_regs.c eeprom.c lite_timer_8bit.c
  group Include Files
    ../inc/: DALIslave.h stm8s_conf.h stm8s_it.h
  group Source Files
    ../src/: DALIslave.c eeprom_itf.c main.c stm8s_it.c
  group STM8S_StdPeriph_Lib/inc
    ../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_flash.h
  group STM8S_StdPeriph_Lib/src
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_flash.c
